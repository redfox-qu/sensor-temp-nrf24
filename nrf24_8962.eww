<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\driverlib\driverlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\nrf24_8962.ewp</path>
  </project>
  <batchBuild/>
</workspace>


