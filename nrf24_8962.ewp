# IAR project nrf24_8962.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: .; src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: nrf24_8962.bin
  ILINK.IlinkOutputFile: nrf24_8962.out
  ILINK.IlinkIcfFile: nrf24_8962.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group library
    driverlib/ewarm/Exe/: driverlib.a
  group source
    src/: ds18b20.c lib_spi.c nrf2401_8962.c nrf24l01.c rfoxm2m.c startup_ewarm.c
  group thirdparty
    thirdparty/: rit128x96x4.c uartstdio.c ustdlib.c
